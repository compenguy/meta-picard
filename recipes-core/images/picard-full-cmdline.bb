# Copyright 2020 Will Page <compenguy@gmail.com>
# SPDX-License-Identifier: MIT

DESCRIPTION = "An image for raspberry pi systems"
LICENSE = "MIT"

require licenses.inc
require picard.inc
require picard-cmdline.inc

IMAGE_ROOTFS_SIZE = "16384"
